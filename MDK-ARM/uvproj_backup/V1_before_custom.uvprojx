# Keil uVision project V1_before_custom.uvprojx, settings and files
target V1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: V1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\LVGL;..\LVGL\lvgl;..\LVGL\generated;..\LVGL\custom;..\LVGL\port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: aht20.c lcd_st7789.c font16.c font32.c font48.c eeprom.c esp_at.c main.c gpio.c dma.c i2c.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c ft5336.c
    ../Core/Inc/: aht20.h lcd_st7789.h font.h eeprom.h esp_at.h ft5336.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group LVGL\lvgl\src/core
    ../LVGL/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group LVGL\lvgl\src/display
    ../LVGL/lvgl/src/display/: lv_display.c
  group LVGL\lvgl\src/draw/dma2d
    ../LVGL/lvgl/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
  group LVGL\lvgl\src/draw
    ../LVGL/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group LVGL\lvgl\src/draw/nema_gfx
    ../LVGL/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_nema_gfx_path.c
  group LVGL\lvgl\src/draw/nxp/g2d
    ../LVGL/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
  group LVGL\lvgl\src/draw/nxp/pxp
    ../LVGL/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
  group LVGL\lvgl\src/draw/nxp/vglite
    ../LVGL/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
  group LVGL\lvgl\src/draw/opengles
    ../LVGL/lvgl/src/draw/opengles/: lv_draw_opengles.c
  group LVGL\lvgl\src/draw/renesas/dave2d
    ../LVGL/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
  group LVGL\lvgl\src/draw/sdl
    ../LVGL/lvgl/src/draw/sdl/: lv_draw_sdl.c
  group LVGL\lvgl\src/draw/sw/blend
    ../LVGL/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
  group LVGL\lvgl\src/draw/sw/blend/neon
    ../LVGL/lvgl/src/draw/sw/blend/neon/: lv_blend_neon.S
  group LVGL\lvgl\src/draw/sw
    ../LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
  group LVGL\lvgl\src/draw/vg_lite
    ../LVGL/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
  group LVGL\lvgl\src/drivers/display/drm
    ../LVGL/lvgl/src/drivers/display/drm/: lv_linux_drm.c
  group LVGL\lvgl\src/drivers/display/fb
    ../LVGL/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
  group LVGL\lvgl\src/drivers/display/ft81x
    ../LVGL/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
  group LVGL\lvgl\src/drivers/display/ili9341
    ../LVGL/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
  group LVGL\lvgl\src/drivers/display/lcd
    ../LVGL/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
  group LVGL\lvgl\src/drivers/display/renesas_glcdc
    ../LVGL/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
  group LVGL\lvgl\src/drivers/display/st7735
    ../LVGL/lvgl/src/drivers/display/st7735/: lv_st7735.c
  group LVGL\lvgl\src/drivers/display/st7789
    ../LVGL/lvgl/src/drivers/display/st7789/: lv_st7789.c
  group LVGL\lvgl\src/drivers/display/st7796
    ../LVGL/lvgl/src/drivers/display/st7796/: lv_st7796.c
  group LVGL\lvgl\src/drivers/display/st_ltdc
    ../LVGL/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
  group LVGL\lvgl\src/drivers/display/tft_espi
    ../LVGL/lvgl/src/drivers/display/tft_espi/: lv_tft_espi.cpp
  group LVGL\lvgl\src/drivers/evdev
    ../LVGL/lvgl/src/drivers/evdev/: lv_evdev.c
  group LVGL\lvgl\src/drivers/glfw
    ../LVGL/lvgl/src/drivers/glfw/: lv_glfw_window.c lv_opengles_debug.c lv_opengles_driver.c lv_opengles_texture.c
  group LVGL\lvgl\src/drivers/libinput
    ../LVGL/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
  group LVGL\lvgl\src/drivers/nuttx
    ../LVGL/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
  group LVGL\lvgl\src/drivers/qnx
    ../LVGL/lvgl/src/drivers/qnx/: lv_qnx.c
  group LVGL\lvgl\src/drivers/sdl
    ../LVGL/lvgl/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
  group LVGL\lvgl\src/drivers/uefi
    ../LVGL/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
  group LVGL\lvgl\src/drivers/wayland
    ../LVGL/lvgl/src/drivers/wayland/: lv_wayland.c lv_wayland_smm.c lv_wl_cache.c lv_wl_dmabuf.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_pointer_axis.c lv_wl_seat.c lv_wl_shell.c lv_wl_shm.c lv_wl_touch.c lv_wl_window.c lv_wl_window_decorations.c lv_wl_xdg_shell.c
  group LVGL\lvgl\src/drivers/windows
    ../LVGL/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
  group LVGL\lvgl\src/drivers/x11
    ../LVGL/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
  group LVGL\lvgl\src/font
    ../LVGL/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group LVGL\lvgl\src/indev
    ../LVGL/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group LVGL\lvgl\src/layouts/flex
    ../LVGL/lvgl/src/layouts/flex/: lv_flex.c
  group LVGL\lvgl\src/layouts/grid
    ../LVGL/lvgl/src/layouts/grid/: lv_grid.c
  group LVGL\lvgl\src/layouts
    ../LVGL/lvgl/src/layouts/: lv_layout.c
  group LVGL\lvgl\src/libs/barcode
    ../LVGL/lvgl/src/libs/barcode/: code128.c lv_barcode.c
  group LVGL\lvgl\src/libs/bin_decoder
    ../LVGL/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group LVGL\lvgl\src/libs/bmp
    ../LVGL/lvgl/src/libs/bmp/: lv_bmp.c
  group LVGL\lvgl\src/libs/expat
    ../LVGL/lvgl/src/libs/expat/: xmlparse.c xmlrole.c xmltok.c xmltok_impl.c xmltok_ns.c
  group LVGL\lvgl\src/libs/ffmpeg
    ../LVGL/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
  group LVGL\lvgl\src/libs/freetype
    ../LVGL/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
  group LVGL\lvgl\src/libs/fsdrv
    ../LVGL/lvgl/src/libs/fsdrv/: lv_fs_arduino_esp_littlefs.cpp lv_fs_arduino_sd.cpp lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
  group LVGL\lvgl\src/libs/gif
    ../LVGL/lvgl/src/libs/gif/: gifdec.c lv_gif.c
  group LVGL\lvgl\src/libs/libjpeg_turbo
    ../LVGL/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
  group LVGL\lvgl\src/libs/libpng
    ../LVGL/lvgl/src/libs/libpng/: lv_libpng.c
  group LVGL\lvgl\src/libs/lodepng
    ../LVGL/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
  group LVGL\lvgl\src/libs/lz4
    ../LVGL/lvgl/src/libs/lz4/: lz4.c
  group LVGL\lvgl\src/libs/qrcode
    ../LVGL/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group LVGL\lvgl\src/libs/rle
    ../LVGL/lvgl/src/libs/rle/: lv_rle.c
  group LVGL\lvgl\src/libs/rlottie
    ../LVGL/lvgl/src/libs/rlottie/: lv_rlottie.c
  group LVGL\lvgl\src/libs/svg
    ../LVGL/lvgl/src/libs/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
  group LVGL\lvgl\src/libs/thorvg
    ../LVGL/lvgl/src/libs/thorvg/: tvgAccessor.cpp tvgAnimation.cpp tvgCanvas.cpp tvgCapi.cpp tvgCompressor.cpp tvgFill.cpp tvgGlCanvas.cpp tvgInitializer.cpp tvgLoader.cpp tvgLottieAnimation.cpp tvgLottieBuilder.cpp tvgLottieExpressions.cpp tvgLottieInterpolator.cpp tvgLottieLoader.cpp tvgLottieModel.cpp tvgLottieModifier.cpp tvgLottieParser.cpp tvgLottieParserHandler.cpp tvgMath.cpp tvgPaint.cpp tvgPicture.cpp tvgRawLoader.cpp tvgRender.cpp tvgSaver.cpp tvgScene.cpp tvgShape.cpp tvgStr.cpp tvgSvgCssStyle.cpp tvgSvgLoader.cpp tvgSvgPath.cpp tvgSvgSceneBuilder.cpp tvgSvgUtil.cpp tvgSwCanvas.cpp tvgSwFill.cpp tvgSwImage.cpp tvgSwMath.cpp tvgSwMemPool.cpp tvgSwPostEffect.cpp tvgSwRaster.cpp tvgSwRenderer.cpp tvgSwRle.cpp tvgSwShape.cpp tvgSwStroke.cpp tvgTaskScheduler.cpp tvgText.cpp tvgWgCanvas.cpp tvgXmlParser.cpp
  group LVGL\lvgl\src/libs/tiny_ttf
    ../LVGL/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
  group LVGL\lvgl\src/libs/tjpgd
    ../LVGL/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group LVGL\lvgl\src
    ../LVGL/lvgl/src/: lv_init.c
  group LVGL\lvgl\src/misc/cache/class
    ../LVGL/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c
  group LVGL\lvgl\src/misc/cache/instance
    ../LVGL/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
  group LVGL\lvgl\src/misc/cache
    ../LVGL/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
  group LVGL\lvgl\src/misc
    ../LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group LVGL\lvgl\src/osal
    ../LVGL/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group LVGL\lvgl\src/others/file_explorer
    ../LVGL/lvgl/src/others/file_explorer/: lv_file_explorer.c
  group LVGL\lvgl\src/others/font_manager
    ../LVGL/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
  group LVGL\lvgl\src/others/fragment
    ../LVGL/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
  group LVGL\lvgl\src/others/gridnav
    ../LVGL/lvgl/src/others/gridnav/: lv_gridnav.c
  group LVGL\lvgl\src/others/ime
    ../LVGL/lvgl/src/others/ime/: lv_ime_pinyin.c
  group LVGL\lvgl\src/others/imgfont
    ../LVGL/lvgl/src/others/imgfont/: lv_imgfont.c
  group LVGL\lvgl\src/others/monkey
    ../LVGL/lvgl/src/others/monkey/: lv_monkey.c
  group LVGL\lvgl\src/others/observer
    ../LVGL/lvgl/src/others/observer/: lv_observer.c
  group LVGL\lvgl\src/others/snapshot
    ../LVGL/lvgl/src/others/snapshot/: lv_snapshot.c
  group LVGL\lvgl\src/others/sysmon
    ../LVGL/lvgl/src/others/sysmon/: lv_sysmon.c
  group LVGL\lvgl\src/others/test
    ../LVGL/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
  group LVGL\lvgl\src/others/vg_lite_tvg
    ../LVGL/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c vg_lite_tvg.cpp
  group LVGL\lvgl\src/others/xml
    ../LVGL/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_parser.c lv_xml_style.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
  group LVGL\lvgl\src/others/xml/parsers
    ../LVGL/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_buttonmatrix_parser.c lv_xml_button_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_event_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
  group LVGL\lvgl\src/stdlib/builtin
    ../LVGL/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group LVGL\lvgl\src/stdlib/clib
    ../LVGL/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group LVGL\lvgl\src/stdlib
    ../LVGL/lvgl/src/stdlib/: lv_mem.c
  group LVGL\lvgl\src/stdlib/micropython
    ../LVGL/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
  group LVGL\lvgl\src/stdlib/rtthread
    ../LVGL/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group LVGL\lvgl\src/stdlib/uefi
    ../LVGL/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group LVGL\lvgl\src/themes/default
    ../LVGL/lvgl/src/themes/default/: lv_theme_default.c
  group LVGL\lvgl\src/themes
    ../LVGL/lvgl/src/themes/: lv_theme.c
  group LVGL\lvgl\src/themes/mono
    ../LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
  group LVGL\lvgl\src/themes/simple
    ../LVGL/lvgl/src/themes/simple/: lv_theme_simple.c
  group LVGL\lvgl\src/tick
    ../LVGL/lvgl/src/tick/: lv_tick.c
  group LVGL\lvgl\src/widgets/3dtexture
    ../LVGL/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
  group LVGL\lvgl\src/widgets/animimage
    ../LVGL/lvgl/src/widgets/animimage/: lv_animimage.c
  group LVGL\lvgl\src/widgets/arc
    ../LVGL/lvgl/src/widgets/arc/: lv_arc.c
  group LVGL\lvgl\src/widgets/bar
    ../LVGL/lvgl/src/widgets/bar/: lv_bar.c
  group LVGL\lvgl\src/widgets/button
    ../LVGL/lvgl/src/widgets/button/: lv_button.c
  group LVGL\lvgl\src/widgets/buttonmatrix
    ../LVGL/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
  group LVGL\lvgl\src/widgets/calendar
    ../LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group LVGL\lvgl\src/widgets/canvas
    ../LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
  group LVGL\lvgl\src/widgets/chart
    ../LVGL/lvgl/src/widgets/chart/: lv_chart.c
  group LVGL\lvgl\src/widgets/checkbox
    ../LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
  group LVGL\lvgl\src/widgets/dropdown
    ../LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
  group LVGL\lvgl\src/widgets/image
    ../LVGL/lvgl/src/widgets/image/: lv_image.c
  group LVGL\lvgl\src/widgets/imagebutton
    ../LVGL/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
  group LVGL\lvgl\src/widgets/keyboard
    ../LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
  group LVGL\lvgl\src/widgets/label
    ../LVGL/lvgl/src/widgets/label/: lv_label.c
  group LVGL\lvgl\src/widgets/led
    ../LVGL/lvgl/src/widgets/led/: lv_led.c
  group LVGL\lvgl\src/widgets/line
    ../LVGL/lvgl/src/widgets/line/: lv_line.c
  group LVGL\lvgl\src/widgets/list
    ../LVGL/lvgl/src/widgets/list/: lv_list.c
  group LVGL\lvgl\src/widgets/lottie
    ../LVGL/lvgl/src/widgets/lottie/: lv_lottie.c
  group LVGL\lvgl\src/widgets/menu
    ../LVGL/lvgl/src/widgets/menu/: lv_menu.c
  group LVGL\lvgl\src/widgets/msgbox
    ../LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
  group LVGL\lvgl\src/widgets/objx_templ
    ../LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
  group LVGL\lvgl\src/widgets/property
    ../LVGL/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
  group LVGL\lvgl\src/widgets/roller
    ../LVGL/lvgl/src/widgets/roller/: lv_roller.c
  group LVGL\lvgl\src/widgets/scale
    ../LVGL/lvgl/src/widgets/scale/: lv_scale.c
  group LVGL\lvgl\src/widgets/slider
    ../LVGL/lvgl/src/widgets/slider/: lv_slider.c
  group LVGL\lvgl\src/widgets/span
    ../LVGL/lvgl/src/widgets/span/: lv_span.c
  group LVGL\lvgl\src/widgets/spinbox
    ../LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
  group LVGL\lvgl\src/widgets/spinner
    ../LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
  group LVGL\lvgl\src/widgets/switch
    ../LVGL/lvgl/src/widgets/switch/: lv_switch.c
  group LVGL\lvgl\src/widgets/table
    ../LVGL/lvgl/src/widgets/table/: lv_table.c
  group LVGL\lvgl\src/widgets/tabview
    ../LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
  group LVGL\lvgl\src/widgets/textarea
    ../LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
  group LVGL\lvgl\src/widgets/tileview
    ../LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
  group LVGL\lvgl\src/widgets/win
    ../LVGL/lvgl/src/widgets/win/: lv_win.c
  group LVGL\custom
    ../LVGL/custom/: custom.c
software components: CMSIS:CORE 4.3.0
