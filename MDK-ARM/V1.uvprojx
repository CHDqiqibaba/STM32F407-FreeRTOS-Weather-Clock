# Keil uVision project V1.uvprojx, settings and files
target V1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: V1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE
  c misc: --diag_suppress=1,188,177,111,129
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../LVGL;../LVGL/lvgl;../LVGL/generated;../LVGL/custom;../LVGL/port;../LVGL/app;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: aht20.c lcd_st7789.c font16.c font32.c font48.c eeprom.c esp_at.c ft5336.c lps22hh.c lis2dh12.c opt3001.c weather.c app_time.c lcd_backlight.c app_freertos.c app_tasks.c ui_msg.c main.c gpio.c dma.c i2c.c iwdg.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
    ../Core/Inc/: aht20.h lcd_st7789.h font.h eeprom.h esp_at.h ft5336.h lps22hh.h lis2dh12.h opt3001.h weather.h app_time.h lcd_backlight.h FreeRTOSConfig.h app_freertos.h app_tasks.h ui_msg.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group LVGL\lvgl\src/core
    ../LVGL/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group LVGL\lvgl\src/display
    ../LVGL/lvgl/src/display/: lv_display.c
  group LVGL\lvgl\src/draw
    ../LVGL/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
  group LVGL\lvgl\src/draw/sw/blend
    ../LVGL/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
  group LVGL\lvgl\src/draw/sw
    ../LVGL/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
  group LVGL\lvgl\src/font
    ../LVGL/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group LVGL\lvgl\src/indev
    ../LVGL/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group LVGL\lvgl\src/layouts/flex
    ../LVGL/lvgl/src/layouts/flex/: lv_flex.c
  group LVGL\lvgl\src/layouts/grid
    ../LVGL/lvgl/src/layouts/grid/: lv_grid.c
  group LVGL\lvgl\src/layouts
    ../LVGL/lvgl/src/layouts/: lv_layout.c
  group LVGL\lvgl\src
    ../LVGL/lvgl/src/: lv_init.c
  group LVGL\lvgl\src/misc/cache/class
    ../LVGL/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c
  group LVGL\lvgl\src/misc/cache/instance
    ../LVGL/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
  group LVGL\lvgl\src/misc/cache
    ../LVGL/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
  group LVGL\lvgl\src/misc
    ../LVGL/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
  group LVGL\lvgl\src/osal
    ../LVGL/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group LVGL\lvgl\src/stdlib/builtin
    ../LVGL/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group LVGL\lvgl\src/stdlib/clib
    ../LVGL/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group LVGL\lvgl\src/stdlib
    ../LVGL/lvgl/src/stdlib/: lv_mem.c
  group LVGL\lvgl\src/stdlib/micropython
    ../LVGL/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
  group LVGL\lvgl\src/stdlib/rtthread
    ../LVGL/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
  group LVGL\lvgl\src/stdlib/uefi
    ../LVGL/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
  group LVGL\lvgl\src/themes/default
    ../LVGL/lvgl/src/themes/default/: lv_theme_default.c
  group LVGL\lvgl\src/themes
    ../LVGL/lvgl/src/themes/: lv_theme.c
  group LVGL\lvgl\src/themes/mono
    ../LVGL/lvgl/src/themes/mono/: lv_theme_mono.c
  group LVGL\lvgl\src/themes/simple
    ../LVGL/lvgl/src/themes/simple/: lv_theme_simple.c
  group LVGL\lvgl\src/tick
    ../LVGL/lvgl/src/tick/: lv_tick.c
  group LVGL\lvgl\src/widgets/3dtexture
    ../LVGL/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
  group LVGL\lvgl\src/widgets/animimage
    ../LVGL/lvgl/src/widgets/animimage/: lv_animimage.c
  group LVGL\lvgl\src/widgets/arc
    ../LVGL/lvgl/src/widgets/arc/: lv_arc.c
  group LVGL\lvgl\src/widgets/bar
    ../LVGL/lvgl/src/widgets/bar/: lv_bar.c
  group LVGL\lvgl\src/widgets/button
    ../LVGL/lvgl/src/widgets/button/: lv_button.c
  group LVGL\lvgl\src/widgets/buttonmatrix
    ../LVGL/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
  group LVGL\lvgl\src/widgets/calendar
    ../LVGL/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
  group LVGL\lvgl\src/widgets/canvas
    ../LVGL/lvgl/src/widgets/canvas/: lv_canvas.c
  group LVGL\lvgl\src/widgets/chart
    ../LVGL/lvgl/src/widgets/chart/: lv_chart.c
  group LVGL\lvgl\src/widgets/checkbox
    ../LVGL/lvgl/src/widgets/checkbox/: lv_checkbox.c
  group LVGL\lvgl\src/widgets/dropdown
    ../LVGL/lvgl/src/widgets/dropdown/: lv_dropdown.c
  group LVGL\lvgl\src/widgets/image
    ../LVGL/lvgl/src/widgets/image/: lv_image.c
  group LVGL\lvgl\src/widgets/imagebutton
    ../LVGL/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
  group LVGL\lvgl\src/widgets/keyboard
    ../LVGL/lvgl/src/widgets/keyboard/: lv_keyboard.c
  group LVGL\lvgl\src/widgets/label
    ../LVGL/lvgl/src/widgets/label/: lv_label.c
  group LVGL\lvgl\src/widgets/led
    ../LVGL/lvgl/src/widgets/led/: lv_led.c
  group LVGL\lvgl\src/widgets/line
    ../LVGL/lvgl/src/widgets/line/: lv_line.c
  group LVGL\lvgl\src/widgets/list
    ../LVGL/generated/: setup_scr_screen_set.c
    ../LVGL/lvgl/src/widgets/list/: lv_list.c
  group LVGL\lvgl\src/widgets/lottie
    ../LVGL/lvgl/src/widgets/lottie/: lv_lottie.c
  group LVGL\lvgl\src/widgets/menu
    ../LVGL/lvgl/src/widgets/menu/: lv_menu.c
  group LVGL\lvgl\src/widgets/msgbox
    ../LVGL/lvgl/src/widgets/msgbox/: lv_msgbox.c
  group LVGL\lvgl\src/widgets/objx_templ
    ../LVGL/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
  group LVGL\lvgl\src/widgets/property
    ../LVGL/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
  group LVGL\lvgl\src/widgets/roller
    ../LVGL/lvgl/src/widgets/roller/: lv_roller.c
  group LVGL\lvgl\src/widgets/scale
    ../LVGL/lvgl/src/widgets/scale/: lv_scale.c
  group LVGL\lvgl\src/widgets/slider
    ../LVGL/lvgl/src/widgets/slider/: lv_slider.c
  group LVGL\lvgl\src/widgets/span
    ../LVGL/lvgl/src/widgets/span/: lv_span.c
  group LVGL\lvgl\src/widgets/spinbox
    ../LVGL/lvgl/src/widgets/spinbox/: lv_spinbox.c
  group LVGL\lvgl\src/widgets/spinner
    ../LVGL/lvgl/src/widgets/spinner/: lv_spinner.c
  group LVGL\lvgl\src/widgets/switch
    ../LVGL/lvgl/src/widgets/switch/: lv_switch.c
  group LVGL\lvgl\src/widgets/table
    ../LVGL/lvgl/src/widgets/table/: lv_table.c
  group LVGL\lvgl\src/widgets/tabview
    ../LVGL/lvgl/src/widgets/tabview/: lv_tabview.c
  group LVGL\lvgl\src/widgets/textarea
    ../LVGL/lvgl/src/widgets/textarea/: lv_textarea.c
  group LVGL\lvgl\src/widgets/tileview
    ../LVGL/lvgl/src/widgets/tileview/: lv_tileview.c
  group LVGL\lvgl\src/widgets/win
    ../LVGL/lvgl/src/widgets/win/: lv_win.c
  group LVGL\lvgl\src\others\sysmon
    ../LVGL/lvgl/src/others/sysmon/: lv_sysmon.c
  group LVGL\lvgl\src\libs\bin_decode
    ../LVGL/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group LVGL\generated
    ../LVGL/generated/: events_init.c gui_guider.c setup_scr_screen_home.c setup_scr_screen_weather.c widgets_init.c setup_scr_screen_log.c setup_scr_screen_sensor.c
  group LVGL\generated/guider_fonts
    ../LVGL/generated/guider_fonts/: lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_SourceHanSerifSC_Regular_10.c lv_font_SourceHanSerifSC_Regular_12.c lv_font_SourceHanSerifSC_Regular_16.c lv_font_SourceHanSerifSC_Regular_48.c lv_font_SourceHanSerifSC_Regular_8.c
  group LVGL\generated/images
    ../LVGL/generated/images/: _wifi_ok_RGB565A8_25x25.c
  group LVGL\custom
    ../LVGL/custom/: custom.c custom.h
  group LVGL\port
    ../LVGL/port/: lv_port_disp.h lv_port_disp.c lv_port_indev.h lv_port_indev.c
  group LVGL\app
    ../LVGL/app/: ui_app.h ui_app.c
  group LVGL
    ../LVGL/: lv_conf.h
  group LVGL\lvgl\src\others\observer
    ../LVGL/lvgl/src/others/observer/: lv_observer.c
  group FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
